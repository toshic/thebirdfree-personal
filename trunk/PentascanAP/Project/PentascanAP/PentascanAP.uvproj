# Keil uVision project PentascanAP.uvproj, settings and files
target FreeRTOS_Demo (ARM-ADS)
  device: LM3S6965 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: RTOSDemo
  AfterMake: fromelf --bin --output .\rvmdk\RTOSDemo.bin .\rvmdk\RTOSDemo.axf
  c flags: Optim=1 OneElfS=1
  c define: RVDS_ARMCM3_LM3S102, "PACK_STRUCT_END=","ALIGN_STRUCT_END=" DEBUG
  c misc: --diag_suppress 191,550,513,167,177,144
  c include: .;..\..\Source\portable\RVDS\ARM_CM3;..\..\Source\include;..\Common\include;..\Common\drivers\Stellarisware\drivers;..\Common\drivers\Stellarisware\grlib;..\Common\drivers\Stellarisware\inc;..\Common\drivers\Stellarisware\lcd;..\Common\FatFs\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler
  group Demo_Source
    ./: main.c startup_rvmdk.S FreeRTOSConfig.h Serial.c Retarget.c httpc.c rtc.c lcd_terminal.c SensorManager.c
    ./ParTest/: ParTest.c
  group Libraries
    ../Common/drivers/Stellarisware/lcd/: rit128x96x4.c
    ../Common/drivers/Stellarisware/: driverlib-cm3.lib grlib-cm3.lib
  group RTOS_Source
    ../../Source/: tasks.c list.c queue.c timers.c
    ../../Source/portable/RVDS/ARM_CM3/: port.c
    ../../Source/portable/MemMang/: heap_3.c
  group lwIP_Source
    ../Common/ethernet/lwip-1.4.0/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Common/ethernet/lwip-1.4.0/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../Common/ethernet/lwip-1.4.0/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../Common/ethernet/lwip-1.4.0/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ../Common/ethernet/lwip-1.4.0/src/netif/: etharp.c ethernetif.c slipif.c
    ../Common/ethernet/lwip-1.4.0/ports/TILM/: stellarisif.c sys_arch.c lwiplib.c
  group FatFs
    ../Common/FatFs/src/: ff.c
    ../Common/FatFs/port/: mmc-ek-lm3s6965.c
    ../Common/FatFs/src/option/: syscall.c cc949.c
